# Keil uVision project xproject.uvprojx, settings and files
target OpenCRP4_MECX1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: xproject +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\Robot;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Driver;..\Driver\ax_mpu6050;..\Driver\ax_mpu6050\eMPL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Robot
    ../Robot/: main.c stm32f10x_it.c system_stm32f10x.c ax_kinematics.c ax_pid.c myiic.c pca9685.c arm.c sys.c
  group Driver
    ../Driver/: ax_delay.c ax_encoder.c ax_led.c ax_motor.c ax_sys.c ax_tim.c ax_uart_db.c ax_uart_pi.c ax_vin.c
    ../Driver/ax_mpu6050/: ax_mpu6050.c ax_mpu6050_dmp.c
    ../Driver/ax_mpu6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group Libraries
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMISS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group Doc
    ../Doc/: ax_readme.txt
